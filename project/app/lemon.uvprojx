# Keil uVision project lemon.uvprojx, settings and files
target nrf51822_lemon (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: Lemon +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110  SOFTDEVICE_PRESENT NRF51 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: ..\include;.\inc;..\source;..\components\softdevice\s110\headers;..\components\libraries\util;..\components\ble\common;..\components\drivers_nrf\ble_flash;..\components\drivers_nrf\hal;..\components\drivers_nrf\pstorage;..\components\drivers_nrf\pstorage\config;..\components\libraries\timer;..\components\libraries\scheduler;..\components\ble\device_manager;..\components\ble\ble_error_log;..\components\softdevice\common\softdevice_handler;..\components\drivers_nrf\simple_uart;..\components\libraries\trace;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\config;..\components\drivers_nrf\common;..\components\device;..\components\drivers_nrf\twi_master\incubated;..\components\ble\ble_db_discovery;..\components\drivers_nrf\wdt;..\components\crc;..\components\ble\ble_services\wechat_service\common;..\components\ble\ble_services\wechat_service;..\components\ble\ble_services\wechat_service\products;..\components\ble\ble_services\wechat_service\wechat_base;..\components\ble\ble_services\wechat_service\sport_simplified
  asm define: BLE_STACK_SUPPORT_REQD S110  SOFTDEVICE_PRESENT NRF51 SPI_MASTER_0_ENABL
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Lemon_app
    ../source/: Aes.c ancs.c base.c batt.c btle.c cp.c dbg.c font.c fs_fat.c fs_file.c fs_flash.c fs_nflash_rw.c fs_root.c gpio.c hal.c homekey.c interrupt.c link.c lis3dh.c main.c nflash_spi.c notific.c oled.c ota.c pedo.c ppg.c butterworth.c reminder.c RTC.c sensor.c sim.c sleep.c spi_master_api.c sysclk.c sysflash_rw.c system.c thermistor.c touch.c tracking.c uart.c ui.c uicoTouch.c user.c uv.c uv_calib.c Watchdog.c weather.c uicoData.c
  group Services
    ../components/ble/common/: ble_srv_common.c
    ../components/ble/ble_services/ble_bas/: ble_bas.c
    ../components/ble/ble_services/ble_dis/: ble_dis.c
    ../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../components/ble/ble_db_discovery/: ble_db_discovery.c
  group Libraries
    ../components/ble/ble_error_log/: ble_error_log.c
    ../components/ble/common/: ble_advdata.c ble_conn_params.c
    ../components/drivers_nrf/ble_flash/: ble_flash.c
    ../components/ble/ble_radio_notification/: ble_radio_notification.c
    ../components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../components/ble/device_manager/: device_manager_peripheral.c
    ../components/libraries/trace/: app_trace.c
  group app_common
    ../components/libraries/timer/: app_timer.c
    ../components/drivers_nrf/pstorage/: pstorage.c
    ../components/libraries/crc16/: crc16.c
  group CRC
    ../components/crc/: crc_16.c crc_abs.c
  group nrf_delay
    ../components/drivers_nrf/hal/: nrf_delay.c
  group sd_common
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nrf_driver
    ../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/hal/: nrf_adc.c
    ../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group wechat
    ../components/ble/ble_services/wechat_service/: ble_wechat_service.c
    ../components/ble/ble_services/wechat_service/wechat_base/: AES2.c comsource.c crc32.c md5.c
    ../components/ble/ble_services/wechat_service/sport_simplified/: wechat_service_sports_simplified.c
    ../components/ble/ble_services/wechat_service/products/: mpbledemo2.c
    ../components/ble/ble_services/wechat_service/common/: ble_wechat_util.c epb.c epb_MmBp.c
    ../source/: wechat_port.c
  group MISC
    ../components/misc/: mics_function.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.20.0, Device:Startup 8.2.0
